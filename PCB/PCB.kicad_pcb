# Repository mfkiwl/M.2-FPGA-Accelerator (continued)

## KiCad design PCB/PCB.kicad_pcb (continued)

Board: 6 copper layers, 22.0 x 80.0 mm, 270 parts (153 on the bottom side), 168 nets.

File PCB/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C101, C103, C126, C130, C133, C134, C141, C142, C15, C152, C153, C159, C160, C166, C167, C2, C21, C22, C23, C32, C33, C37, C40, C41, C42, C43, C44, C56, C66, C68, C70, C87, C89, C90, C94, C98",0603,37,4u7,
"C10, C11, C12, C3, C4, C5, C6, C7, C8, C9",0402,10,220n,
"C100, C102, C104, C105, C106, C107, C108, C109, C118, C124, C125, C127, C129, C135, C136, C137, C138, C143, C144, C145, C146, C148, C150, C151, C154, C155, C156, C157, C161, C162, C163, C164, C168, C169, C17, C170, C171, C18, C19, C20, C25, C27, C28, C29, C30, C31, C35, C36, C38, C39, C47, C54, C55, C67, C69, C71, C91, C92, C95, C99",0201,60,470n,
"C110, C111, C113, C114, C115, C116, C117, C119, C120, C122, C123, C139, C14, C16, C57, C58, C59, C60, C61, C62, C63, C64, C65, C73, C74, C76, C77, C78, C79, C80, C81, C82, C83, C84, C86, C93",0402,36,100n,
"C112, C121, C46",0402,3,1u,
"C128, C72",0603,2,47n,
"C13, C172",0402,2,10n,
"C131, C132, C140, C147, C149, C158, C165, C34, C45, C49, C51, C53, C75, C85, C88",1206,15,47u,
C24,CP_EIA-3528-21_Kemet-B,1,330u,C542287
C26,1206,1,100u,C15008
C48,0402,1,68pF,
"C50, C96, C97",0402,3,33p,
C52,0402,1,22pF,
"D1, D2",0805,2,KT-0805Y,C2296
D3,D_SOD-323,1,1N5819WS,1N5819WS
D4,0805,1,KT-0805G,C2297
"FB1, FB2",0805,2,120@100MHz,C5120901
J1,M.2 M-Key 2242,1,Bus_M.2_Edge_M,
J4,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,TYPE-C-31-M-12,C165948
J7,HDMI_Micro-D_Molex_46765-1xxx,1,HDMI_D_1.4,C711358
"L1, L2, L3, L4, L6",L_Sunlord_SWPA4030S,5,1u5,C42100
"R1, R31",0402,2,100,
"R10, R11, R12, R13, R34, R38, R39, R40, R41, R45, R46, R5, R51, R53, R54, R7, R9",0402,17,10k,
"R14, R15, R17, R18, R2, R24, R3, R42, R43, R44, R56, R57, R76, R77",0402,14,1k,
R16,0402,1,240,
"R19, R20, R21, R22, R23, R27, R28, R30, R59, R60, R61, R62",0402,12,4k7,
"R25, R26, R29, R32, R36, R37, R75",0402,7,22,
"R33, R47",0603,2,30k,
"R35, R6",0603,2,4k99,
R4,0402,1,2k,
"R48, R49",0402,2,5k1,
R52,0402,1,2k2,
R55,0402,1,12k,
"R58, R65",0402,2,100k,
R8,0603,1,8k2,
SW1,SW_SPST_TS-1088-xR020,1,SW_Push,C720477
U1,Xilinx_FGG484,1,XC7A50T-FGG484,
U10,QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm,1,FT2232HQ,
U11,FBGA-96_8x14mm_Layout9x16_P0.8mm,1,MT41J128M16JT-125:K,C426885
U12,VSSOP-8_2.3x2mm_P0.5mm,1,PCA9306DC1,C129510
"U14, U15, U16",Diodes_UDFN-10_1.0x2.5mm_P0.5mm,3,UCL0524P,C2835428
U17,VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias,1,TPS62132,
U2,QFN-28_L5.0-W5.0-P0.50-TL-EP3.2,1,MAX20029ATIA/V+,C1235515
"U3, U4, U6",Texas_DRT-3,3,TPD2EUSB30,
U5,Texas_VQFN-HR-12_2x2.5mm_P0.5mm_ThermalVias,1,TPS2121RUXR,C485916
U7,W-PDFN-8-1EP_6x5mm_P1.27mm_EP3x3mm,1,MT25QL128ABA1EW7-0SIT,C2887898
U9,SOIC-8_3.9x4.9mm_P1.27mm,1,M93C56-WMN6TP,
Y2,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,12MHz,C9002
Y3,Oscillator_SMD_SiT_PQFN-4Pin_5.0x3.2mm,1,100MHz,C78882

## Commit log

2026-01-18 cleaning up USB-C, switching some of the decoupling and assigning a bunch of footprints
2026-01-18 even more footprints
2026-01-18 added the basic form factor
2026-01-18 finished add in all the footprints
2026-01-18 changed the m.2 footprint to 2280
2026-01-18 fixed my FPGA footprint for use with my symbol
2026-01-18 set up my clearance for JLC
2026-01-19 changiing DRC drill/diameter
2026-01-19 setting up basic netclasses, so assigning yet
2026-01-19 doing netclass pattern stuff, this is hard
2026-01-19 assigning most of the net classes
2026-01-19 adding the proper 100uF caps
2026-01-19 fixing a bunch of footprints to standardize
2026-01-19 organizing all the FPGA components on the PCB
2026-01-20 journaled about HDMI
2026-01-20 added in ethernet to the journal!
2026-01-20 replacing the HDMI connector with micro HDMI
2026-01-20 adding some MPN's in, searching for ethernet RJ45's
2026-01-21 working on a new ethernet connector
2026-01-21 removing ethernet, out of scope ;)
2026-01-21 workingng on organizing the board
2026-01-21 cleaning up the schematic
2026-01-21 switched to 6 layer board, starting to organize stuff
2026-01-21 working on organizing the buck
2026-01-21 completely organized the MAX20029 buck and cleaned up some silkscreen
2026-01-21 organizing the power mux for routing
2026-01-22 working on organizing some HDMI
2026-01-22 organizing PCIe
2026-01-22 cleaning up the silkscreen, inrush caps and other stuff
2026-01-22 added a keep out to my m.2 edge connector, moving the AC/dampening and cleaning up back silkscreen
2026-01-22 organized EEPROM, I2C level shifter
2026-01-22 cleaned up the schematic to look cooler
2026-01-22 forgot to create the bus alias definitions for uart and jtag
2026-01-22 updated PCB refs
2026-01-22 cleaning up the ft2232H decoupling, laying it out on the PCB too
2026-01-22 cleaning up the silkscreen from the new components
2026-01-22 laying out the FT2232H
2026-01-22 cleaning up the board, need to add a courtyard to my quad buck :/
2026-01-22 heading to the next class, some minor changes
2026-01-22 wiring a terrible USB buck layout, buck might be too big?
2026-01-23 forgot to add decouping to my banks
2026-01-23 fixed my decoupling because I'm better than the datasheet
2026-01-23 tuning via/trace sizes for decoupling fanout
2026-01-23 VCCINT decoupling fanout
2026-01-23 finished routing VCCINT
2026-01-23 working on VCCBRAM and VCCADC fanout
2026-01-23 wired VCCBRAM and VCCADC, working on VCCAUX
2026-01-23 ground fill and some more routing
2026-01-23 finished VCCAUX
2026-01-23 starting to wire bank decoupling
2026-01-23 wired decoupling to banks 34 and 35
2026-01-23 decoupling fanout for 3V3 and 1V5
2026-01-23 bank 14 decoupling finished
2026-01-23 decoupled bank 13
2026-01-23 decoupled bank 15
2026-01-23 decoupling bank 34
2026-01-23 finished decoupling bank 35
2026-01-23 wired up bank 16
2026-01-23 fanout bank 16
2026-01-23 finished bank 16 decoupling
2026-01-23 cleaning up silkscreen
2026-01-23 Updating readme with current progress!
2026-01-23 plotted new schematic PDF for others!
2026-01-23 routing aa bunch of grounds for simple routing
2026-01-24 faning out GTP decoupling
2026-01-24 finished decoupling the GTP transceivers!
2026-01-24 cleaning up silkscreen and some routing
2026-01-24 getting ready for DDR routing
2026-01-24 did the DDR3 decoupling fanout
2026-01-24 routed DDR3 VDD
2026-01-24 finished decoupling my DDR3!
2026-01-24 cleaning up the silkscreen
2026-01-24 fixing my VREF decoupling, starting to route it!
2026-01-24 finished routing VREF
2026-01-24 cleaning up silkscreen and isolating the traces some more
2026-01-25 organizing stuff to get ready for DDR routing!
2026-01-25 starting to route
2026-01-26 changing stackups
2026-01-26 changing LAYER stackup
2026-01-26 working on custom netclasses
2026-01-27 finally got my settings in check!
2026-01-27 DDR signal fanout
2026-01-27 working on DDR3 routing, this is going to be rough...
2026-01-27 DDR command netclasses and some more routing
2026-01-27 faning out more DDR3, crosstalk looking BAD
2026-01-27 minimizing crosstalk and adding in CLK net class
2026-01-27 faned out all my I/O's
2026-01-27 working on routing innner layers
2026-01-29 some beautiful inner layer routing
2026-01-29 BANG, all those inner tracesgit add .
2026-01-29 cleaned up the backside DDR traces
2026-01-29 managed to fit in all the traces, but ruined my cleaning up
2026-01-29 cleaning up DDR3 inner traces
2026-01-29 cleaned up top layer
2026-01-29 finished all of the DDR3 fanout!
2026-01-29 silkscreen and trace cleanup
2026-01-30 fixing my pads
2026-01-30 let's redo our entire DDR routing
2026-01-30 top DDR routing
2026-01-30 bottom DDR decoupling
2026-01-30 some vref routing too
2026-01-31 full dogbone fanout
2026-01-31 fanned out every singel signal I think
2026-01-31 finished spacing out the inner layer
2026-01-31 adjusted the top layer and inner a bit more
2026-01-31 finished the IO fanout
2026-01-31 modifying DDR3 CS, routing it too
2026-01-31 found a couple stray pins not routed, finally did themgit add .
2026-01-31 finished my DDR fanout after adding the pulldowns
2026-01-31 hopping off for the night, looking sick!
2026-01-31 frouting DDR to the FPGA
2026-02-01 more IO routing
2026-02-01 routed top and inner DDR, working on bottom!
2026-02-01 re-routed top, stupid initial route
2026-02-01 fixed the bbottom routinggit add .
2026-02-01 adjusting top and bottom
2026-02-01 omg I'm so stupid, my routing is way easier because I had some pins routed on multiple layersgit add .
2026-02-01 managed to route everything, albeit pretty terribly!
2026-02-02 doing a lot more routing
2026-02-02 bottom/top layer redo
2026-02-02 routing inner layers
2026-02-02 cleaning up some traces
2026-02-03 starting to actually put the DDR traces to their pins
2026-02-03 a bunch more routing and assigning, really messy but coming along
2026-02-03 finished routing all the pins, very messy still
2026-02-03 moving traces to reduce crosstalk
2026-02-04 almost done vivado memory verification
2026-02-04 heading to school
2026-02-04 finally routed a little mischevious DQ3
2026-02-04 heading out from school
2026-02-06 TRYING TO GET THIS TRACE THROUGH FEHJFSHEJKF
2026-02-06 let's redo this!
2026-02-06 technically layed out everything out I think finally
2026-02-06 minor adjustements, can't believe I did it
2026-02-07 a bunch of wiring
2026-02-07 finished wiring
2026-02-07 a bunch of routing
2026-02-07 vivado stuff
2026-02-08 5th time routing is the charm EHH :D
2026-02-08 manifesting pins out of nowhere
2026-02-09 OH MY, gotta move some bottom traces and then it'll be good :D
2026-02-09 KJFESKJFHSEKJFEHSFES
2026-02-10 slowly going insane with this routing
2026-02-10 SO CLOSE
2026-02-10 BANNGNGHNGBEN SKGJHB EHGSEFHSEIUGHSE
2026-02-10 heading out of school
2026-02-11 LOTS of progress, almost done!
2026-02-11 cleaned up some stuff, heading to sleep :D
2026-02-11 somehow put DQS pairs not on the specific data byte......................
2026-02-11 BANNNG
2026-02-12 KFNESIFHESKJFHSEKJFH UI DID IT
2026-02-12 more vivado errors :/
2026-02-12 To schooll!
2026-02-12 I'MMMMM crashing out
2026-02-12 GOD TIER DQS pair layer switch to reduce reflections
2026-02-12 heading back home
2026-02-13 I THINK I DID IT
2026-02-13 I didn't do it lol
2026-02-14 OKAY THIS SHOULD ACTUALLY BE GOOD NOW
2026-02-14 YESSSS MY LAYOUT IS FINALLY VALIDDDD
2026-02-14 working o on organization
2026-02-14 hopping off for now, I think this will come to me in the morning ;)
2026-02-14 working on cleaning up the inner traces
2026-02-14 finished organizing the inner layers JHFESJKFHESJKFHES
2026-02-14 cleaning up the traces even more, it's beautiful :D
2026-02-14 BANNNG valid and cleaned up the schematic :D, next skew/length matching and finishing MIG
2026-02-15 skew matching differential pairs
2026-02-15 some adjusting, trynna figure out how to do this :/
2026-02-15 working on re-organizing for length matching, this is going to take a WHILE
2026-02-16 this is annoying
2026-02-16 OKAY LFIRST BIG WIN FOR LENGTH MATCHING
2026-02-16 15mm and 33mm of max distance, only 18mmgit add . gotta get that smaller though :/
2026-02-16 HIGHKEY COOKING
2026-02-16 GOATED length matching
2026-02-16 aGOING REALLY WELL :D
2026-02-16 adjusting all the via fanouts to 50R SE
2026-02-16 trynna breakout my config pins :/
2026-02-17 broke out my configuration pins, that took too long
2026-02-17 fixing my length matching :D
2026-02-17 trying to fit in all of the config passive :/
2026-02-17 heading home
2026-02-18 technically routed up all my config passives, but it's a bit messy :/
2026-02-18 OKAY THIS ACTUALLY WORKS, it's real jank though lol
2026-02-18 cleaning up some traces, improving the plane
2026-02-18 BANG! GGood to go breakout, more length matching time :D
2026-02-18 finished length matching the third byte group!
2026-02-18 some quick length matching before I go to sleep I GOT THIS
2026-02-18 length matching go BRRR
2026-02-18 some mad good length matching :D
2026-02-18 a bunch of work, length matching, moving traces
2026-02-19 hopping off for the night, big progress!
2026-02-19 finally got CKE matched!
2026-02-19 doing some quick length matching at school
2026-02-20 I think that's all the data traces matched!
2026-02-20 bunch of length matching
2026-02-20 GENUINE progress, getting so close, hardest last stretch now
2026-02-21 huge progress, locked in!
2026-02-21 heading to sleep, the final stretch!
2026-02-21 getting crazy with this length matching
2026-02-22 cleaning stuf up
2026-02-22 just a couple more traces to length match!
2026-02-22 tuning up the inner layer length
2026-02-23 a bunch of progress
2026-02-23 Getting so crowded, barely any space left :/
2026-02-23 slowly but surely
2026-02-25 BANG, another line matched
2026-02-25 another line matched
2026-02-25 final stretchgit add .!
2026-02-25 length matched another one!!g
2026-02-26 another line matched, just 2 left I think!
2026-02-26 big progress, last little stretch!
2026-02-26 restoring backup because my project crashed on school computers :/
2026-02-27 another line length matched!
2026-02-27 opening up space for the final length match!
2026-02-27 everything preliminarily length matched!
2026-02-27 starting to clean stuff up
2026-02-28 cleaning more stuff up
2026-02-28 even more cleanup
2026-02-28 moving to V10, cleaning stuff up too :D
2026-03-03 working on routing USB and JTAG
2026-03-04 a bunch of progress!
2026-03-04 a bunch more progress
2026-03-04 bunch of progress!
2026-03-05 a bunch more routing, some layout stuff too
2026-03-05 increasing layout density
2026-03-06 backup
2026-03-06 cleaning up the layout to allow more space for the crystal
2026-03-06 trying to fit in some large caps, this is going to take a while...
2026-03-06 New photo's!
2026-03-07 adding return via's and cleaning up the schematic a bit!
2026-03-07 cleaning up custom drc and some other stuff!
2026-03-07 a bunch of layout stuff
2026-03-07 proper DDR3 decoupling!
2026-03-07 working on unused bank decoupling, I think I can just remove most of these?
